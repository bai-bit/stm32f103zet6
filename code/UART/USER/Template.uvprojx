# Keil uVision project Template.uvprojx, settings and files
target led (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F403ZG ArteryTek
  pack: Keil.AT32F4xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403Zx_XL
  c include: ..\AT32F4XX_FWLib\CoreSupport;..\AT32F4XX_FWLib\DeviceSupport;..\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ./: main.c
  group hardware
    ../HARDWARE/: gpio_init.c HW_SysTick.c led.c nvic.c uart.c getclock.c strfunc.c
    ../AT32F4XX_FWLib/src/: at32f4xx_rcc.c
  group core
    ../CORE/: startup_at32f403cx_xl.s
  group system
    ../SYSTEM/: system_at32f4xx.c
