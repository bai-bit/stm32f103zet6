# Keil uVision project Template.uvprojx, settings and files
target UART1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F403ZG ArteryTek
  pack: Keil.AT32F4xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403Zx_XL
  c include: ..\..\..\Libraries\drivers\inc;..\..\..\Libraries\startup\DeviceSupport;..\..\..\Libraries\startup\CoreSupport
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group USER
    ../src/: main.c
  group drivers
    ../../../Libraries/drivers/src/: getclock.c gpio_init.c HW_SysTick.c led.c nvic.c strfunc.c uart.c exti.c
  group startup
    ../../../Libraries/startup/DeviceSupport/: system_at32f4xx.c
    ../../../Libraries/startup/DeviceSupport/startup/mdk/: startup_at32f403zx_xl.s
